Commit message: add mesh

File: src/hexapod_desc/urdf/hexapod.urdf (robot description, URDF)
Before this commit: robot visual, 5 links, 4 joints
Links:
- link leg_2: geometry visual mesh filename=package://hexapod_desc/meshes/foot_ground.dae
